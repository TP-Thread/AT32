# IAR project at32f421k8.ewp, settings and files
configuration at32f421k8 (ARM, debug)
  General.OGChipSelectEditMenu: AT32F421K8U7_v2 ArteryTek -AT32F421K8U7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: AT32F421K8U7; USE_STDPERIPH_DRIVER; AT_START_F421_V1
  ICCARM.CCIncludePath2: ..\..\libraries\drivers\inc; ..\..\libraries\cmsis\cm4\core_support; ..\..\libraries\cmsis\cm4\device_support; ..\inc; ..\..\bsp\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: at32f421k8.srec
  ILINK.IlinkOutputFile: at32f421k8.out
  ILINK.IlinkIcfFile: AT32F421x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group bsp
    ../../bsp/src/: ar_tim.c ar_water_det.c
  group cmsis
    ./: startup_at32f421.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f421.c
  group firmware
    ../../libraries/drivers/src/: at32f421_crm.c at32f421_tmr.c at32f421_gpio.c at32f421_usart.c at32f421_pwc.c at32f421_adc.c at32f421_dma.c at32f421_debug.c at32f421_flash.c at32f421_exint.c at32f421_misc.c at32f421_scfg.c
  group user
    ../src/: at32f421_int.c at32f421_wk_config.c main.c wk_system.c
