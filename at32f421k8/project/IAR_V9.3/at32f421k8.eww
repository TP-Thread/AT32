<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\at32f421k8.ewp</path>
    </project>
    <batchBuild />
</workspace>
