# IAR project at32f423rc.ewp, settings and files
configuration at32f423rc (ARM, debug)
  General.OGChipSelectEditMenu: AT32F423RCT7_v2 ArteryTek -AT32F423RCT7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32F423RCT7; USE_STDPERIPH_DRIVER; AT_START_F423_V1
  ICCARM.CCIncludePath2: ..\..\libraries\drivers\inc; ..\..\libraries\cmsis\cm4\core_support; ..\..\libraries\cmsis\cm4\device_support; ..\inc; ../../middlewares/freertos/source/include; ../../middlewares/freertos/source/portable/memmang; ../../middlewares/freertos/source/portable/IAR/ARM_CM4F
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: at32f423rc.srec
  ILINK.IlinkOutputFile: at32f423rc.out
  ILINK.IlinkIcfFile: AT32F423xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group cmsis
    ./: startup_at32f423.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f423.c
  group firmware
    ../../libraries/drivers/src/: at32f423_crm.c at32f423_gpio.c at32f423_pwc.c at32f423_adc.c at32f423_debug.c at32f423_flash.c at32f423_exint.c at32f423_misc.c at32f423_scfg.c
  group user
    ../src/: at32f423_int.c at32f423_wk_config.c main.c freertos_app.c wk_adc.c wk_exint.c
  group middlewares/freertos
    ../src/: freertos_app.c wk_adc.c wk_exint.c
    ../../middlewares/freertos/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c stream_buffer.c
    ../../middlewares/freertos/source/portable/IAR/ARM_CM4F/: port.c portasm.s
    ../../middlewares/freertos/source/portable/memmang/: heap_4.c
